FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-nfs-setup.patch file://0002-bootdelay.patch"

